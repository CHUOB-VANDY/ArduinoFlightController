# Repository CHUOB-VANDY/ArduinoFlightController

## KiCad design ArduinoFlightController.kicad_pcb

Board: 4 copper layers, 40.5 x 40.5 mm, 45 parts (0 on the bottom side), 35 nets.

Parts:
C1, C2, C3, C4, C7, C9, C12, C13, C15, C16: 100nF; C_0603_1608Metric
C5, C6: 22pF; C_0603_1608Metric
C8: 4.7uF; C_0805_2012Metric
C10: 10uF; CP_EIA-3216-10_Kemet-I
C11: 10nF; C_0603_1608Metric
C14: 2.2nF; C_0603_1608Metric
D1, D2: LEDR; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3mm_Pad_Via
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_XKB_U262-16XN-4BVC11
J2: PWM_PIN; pad_01x06
J3: RC_IN; pad_01x06
J4, J5, J6, J7, J8: Conn_01x02; pad_01x02
R1: 10k; R_0603_1608Metric
R2, R3: 4k7; R_0603_1608Metric
R4, R5: 22R; R_0603_1608Metric
R6, R7, R8, R9: 1k; R_0603_1608Metric
SW1: NRST; SW_SPST_B3U-1000P
U1: ATmega328P-A; TQFP-32_7x7mm_P0.8mm
U2: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U3: LP2985-3.3; SOT-23-5
U4: CH330N; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C10.1, C11.1, C12.2, J5.2, J7.2, R2.1, R3.1, U2.8 (VDDIO), U2.13 (VDD), U3.5 (VOUT)
+5V: C1.1, C2.1, C3.1, C4.1, C8.1, C15.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J4.2, J6.2, J8.2, R1.2, R9.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U1.20 (AREF), U3.1 (VIN), U3.3 (ON/~OFF), U4.5 (VCC)
/A0: J2.5, U1.23 (PC0)
/A1: J2.6, U1.24 (PC1)
/BP: C9.1, U3.4 (BP)
/CPOUT: C14.1, U2.20 (CPOUT)
/D2: J3.1, U1.32 (PD2)
/D3: J2.1, U1.1 (PD3)
/D4: J3.2, U1.2 (PD4)
/D5: J3.3, U1.9 (PD5)
/D6: J3.4, U1.10 (PD6)
/D7: J3.5, U1.11 (PD7)
/D8: J3.6, U1.12 (PB0)
/D9: J2.2, U1.13 (PB1)
/D10: J2.3, U1.14 (PB2)
/D11: J2.4, U1.15 (PB3)
/D13: R8.1, U1.17 (PB5)
/D+: J1.A6 (D+), J1.B6 (D+), R5.1
/D-: J1.A7 (D-), J1.B7 (D-), R4.1
/REGOUT: C13.1, U2.10 (REGOUT)
/RESET: C7.1, R1.1, SW1.1, U1.29 (~RESET/PC6)
/RX: R7.1, U4.7 (RXD)
/SCL: R2.2, U1.28 (PC5), U2.23 (SCL)
/SDA: R3.2, U1.27 (PC4), U2.24 (SDA)
/TX: R6.1, U4.6 (TXD)
/UART_RX: R6.2, U1.30 (PD0)
/UART_TX: R7.2, U1.31 (PD1)
/UD+: R4.2, U4.2 (UD-)
/UD-: R5.2, U4.1 (UD+)
/V3: C16.2, U4.8 (V3)
/XTAL1: C6.1, U1.7 (XTAL1/PB6), Y1.3
/XTAL2: C5.1, U1.8 (XTAL2/PB7), Y1.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.2, C14.2, C15.1, C16.1, D1.1 (K), D2.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J4.1, J5.1, J6.1, J7.1, J8.1, SW1.2, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.1 (CLKIN), U2.9 (AD0), U2.11 (FSYNC), U2.18 (GND), U3.2 (GND), U4.3 (GND), Y1.2, Y1.4
unnamed: D1.2 (A), R8.2
unnamed: D2.2 (A), R9.2

## Commit log

2022-09-29 add logo
